# Keil uVision project Sensors.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Sensors +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000120 size 0x2000
  scatter file: .\Objects\Sensors.sct
  group main
    ./src/: ad7091.c main.c setup.c usart.c gpio_init.c Main_thread.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
